FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://patch-u-boot-v2013.07/0001-add-u-boot-config.patch"

