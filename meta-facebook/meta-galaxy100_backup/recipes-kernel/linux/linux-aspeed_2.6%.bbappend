LINUX_VERSION_EXTENSION = "-galaxy100"

COMPATIBLE_MACHINE = "galaxy100"

KERNEL_CONFIG_COMMAND = "oe_runmake galaxy100_defconfig && oe_runmake oldconfig"
