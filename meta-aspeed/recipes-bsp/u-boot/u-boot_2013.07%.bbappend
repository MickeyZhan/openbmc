FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI = "file://u-boot-v2013.07 \
          "

PV = "v2013.07"

S = "${WORKDIR}/u-boot-v2013.07"
